options:
  parameters:
    author: Juan
    generate_options: qt_gui
    id: practica41
    output_language: python
    title: Transmisor AM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: '1E-4'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '1E-4'
    stop: '1'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: 50E6
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente ka
    start: '0'
    step: '100E-6'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: '200000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: calculoPotencia_0
  id: calculoPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: envolvente_0
  id: envolvente
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: '200000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', calculoPotencia_0, '0']
- [analog_sig_source_x_0, '0', envolvente_0, '0']
- [envolvente_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
