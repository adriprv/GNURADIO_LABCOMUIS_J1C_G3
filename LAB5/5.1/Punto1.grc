options:
  parameters:
    author: Grupo_J1C03
    copyright: Grupo_J1C03
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulacion_PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud_Portadora
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud_Mensaje
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frec Portadora
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_Mensaje
    start: 1e3
    step: '100'
    stop: 20e3
    value: 10e3
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente_Kp
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/16
  states: {}
- name: CalculoPotenciaComuG03_0
  id: CalculoPotenciaComuG03
  parameters:
    I_vect: '1024'
  states: {}
- name: Envolvente_Cp_PM_0
  id: Envolvente_Cp_PM
  parameters:
    Ac: Ac
    Kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_Cp_PM_0, '0', blocks_complex_to_mag_0, '0']
- [Envolvente_Cp_PM_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Cp_PM_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_Cp_PM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Cp_PM_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotenciaComuG03_0, '0']

metadata:
  file_format: 1
